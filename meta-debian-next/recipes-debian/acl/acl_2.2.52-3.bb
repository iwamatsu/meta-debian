inherit debian-package
